FILESEXTRAPATHS_prepend := "${THISDIR}/sabre-files:"

SRC_URI += "file://defconfig"
