FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-u-boot-CONFIG_SD_BOOT-y.patch"

